# Keil uVision project mdk_app.uvprojx, settings and files
target mdk_app (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: mdk_app
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32F407xx, SYSTEM_ARCH_RTOS=1
  c misc: -DHSE_VALUE=8000000 --diag_suppress=188,177,550,940,66,546 --gnu -DUSE_BOOTLOADER=1 -DUSE_USB_HOST_UART=1
  c include: ..\..\..\..\..\..\..\psdk_lib\include;..\..\..\..\..\module_sample;..\..\..\common\osal;..\..\application;..\..;..\..\hal;..\..\drivers\BSP;..\..\drivers\CMSIS\Include;..\..\drivers\Device\ST\STM32F4xx;..\..\drivers\STM32F4xx_HAL_Driver\Inc;..\..\drivers\USB_HOST\App;..\..\drivers\USB_HOST\Target;..\..\middlewares\ST\STM32_USB_Host_Library\Class\CDC\Inc;..\..\middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\middlewares\Third_Party\FreeRTOS\Source\include;..\..\middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\module_sample\widget;..\..\..\..\..\module_sample\widget\widget_file_c\en_big_screen;..\..\..\..\..\..\..\glink_ftp;..\..\..\..\..\module_sample\upgrade;..\..\..\..\..\..\..\psdk_lib\lib_src;..\..\..\..\..\module_sample\utils;..\..\..\..\..\..\..\psdk_lib\cJSON;..\..\..\..\..\..\..\develop_project\code\psdk_lib\include;..\..\..\..\..\..\..\develop_project\code\glink_ftp;..\..\..\..\..\..\..\develop_project\code\glink;..\..\..\..\..\..\..\develop_project\code\cJSON;..\..\..\..\..\..\..\develop_project\code\glink\glink_m\MobileTerminal\APP;..\..\..\..\..\..\..\develop_project\code\glink\glink_m\MobileTerminal;..\..\..\..\..\..\..\develop_project\code\psdk_lib\include;..\..\..\..\..\..\..\glink;..\..\..\..\..\..\..\glink\glink_m;..\..\..\..\..\..\..\glink\glink_np
  asm misc: --cpreproc --cpreproc_opts=-DUSE_HAL_DRIVER,-DSTM32F407xx,-DSYSTEM_ARCH_RTOS=1
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x20000
  group application
    ../../application/: application.c main.c
    ../../hal/: hal_uart.c
    ../../../common/osal/: osal.c
  group bsp
    ../../drivers/BSP/: flash_if.c freertos.c led.c pps.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c system_stm32f4xx.c uart.c gdu_ringbuffer.c apply_high_power.c upgrade_platform_opt_stm32.c
    ../../drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../../middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
    ../../middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group drv/stm32f4_hal_driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group include
    ../../application/: application.h FreeRTOSConfig.h
    ../../middlewares/Third_Party/FreeRTOS/Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ../../drivers/BSP/: button.h flash_if.h led.h pps.h stm32f4xx_hal_conf.h stm32f4xx_it.h sysmem.h uart.h
    ../../drivers/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    ../../middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.h
    ../../hal/: hal_uart.h
    ../../../common/osal/: osal.h
    ../../middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: portmacro.h
    ../../drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_exti.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_ll_usb.h
    ../../drivers/USB_HOST/App/: usb_host.h
    ../../middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc/: usbh_cdc.h
    ../../drivers/USB_HOST/Target/: usbh_conf.h
    ../../middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_def.h usbh_ioreq.h usbh_pipes.h
  group lib
    ../../../../../../../psdk_lib/lib/armcc_cortex-m4/: mdk_app.lib
  group mid/freertos/port
    ../../middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group mid/freertos/src
    ../../middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group usb_host
    ../../drivers/USB_HOST/App/: usb_host.c
    ../../drivers/USB_HOST/Target/: usbh_conf.c
  group api_sample
    ../../../../../module_sample/camera_emu/: test_payload_cam_emu_base.c
    ../../../../../module_sample/fc_subscription/: test_fc_subscription.c
    ../../../../../module_sample/gimbal_emu/: test_payload_gimbal_emu.c
    ../../../../../module_sample/positioning/: test_positioning.c
    ../../../../../module_sample/time_sync/: test_time_sync.c
    ../../../../../module_sample/utils/: util_buffer.c util_file.c util_md5.c util_misc.c util_time.c
    ../../../../../module_sample/power_management/: test_power_management.c
    ../../../../../module_sample/widget/: file_binary_array_list_en.c test_widget.c test_widget_speaker.c
    ../../../../../module_sample/upgrade/: test_upgrade.c test_upgrade_common_file_transfer.c test_upgrade_platform_opt.c
    ../../../../../module_sample/flight_control/: test_flight_control.c
    ../../../../../module_sample/ppk/: test_playload_ppk.c
    ../../../../../module_sample/hms/: test_hms.c
    ../../../../../module_sample/data_transmission/: test_data_transmission.c
    ../../../../../module_sample/camera_manager/: test_camera_manager.c
  group lib_src
    ../../../../../../../develop_project/code/psdk_lib/src/: baseMsgHandle.c gdu_aircraft_info.c gdu_cache.c gdu_core.c gdu_flight_controller.c gdu_gimbal.c gdu_glink.c gdu_liveview.c gdu_logger.c gdu_payload_camera.c gdu_payload_camera_media.c gdu_platform.c gdu_positioning.c gdu_power_management.c gdu_ppk.c gdu_serial.c gdu_subscribeInfo.c gdu_upgrade.c gdu_waypoint_v3.c gdu_widget.c gdu_widget_speaker.c general_linked_list.c npc.c position_calculate.c time_sync.c gdu_hms.c data_transmission.c gdu_camera_manager.c
  group cJSON
    ../../../../../../../develop_project/code/cJSON/: cJSON.c
software components: CMSIS:CORE 5.0.1
